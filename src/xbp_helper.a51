#include "stc15fxxxx.inc"

EXTERN DATA (?C_XBP)

SEG_XBPHELPER SEGMENT CODE
RSEG SEG_XBPHELPER

	PUBLIC _GETXBP, GETXBP
	_GETXBP:
	GETXBP:
		JBC EA, GETXBP_SETEA
			MOV R6, ?C_XBP
			MOV R7, ?C_XBP + 1
			RET
		GETXBP_SETEA:
			MOV R6, ?C_XBP
			MOV R7, ?C_XBP + 1
			SETB	EA
			RET

	PUBLIC _SETXBP, SETXBP
	_SETXBP:
	SETXBP:
		JBC EA, SETXBP_SETEA
			MOV ?C_XBP, R6
			MOV ?C_XBP + 1, R7
			RET
		SETXBP_SETEA:
			MOV ?C_XBP, R6
			MOV ?C_XBP + 1, R7
			SETB	EA
			RET




END